# Keil uVision project GONGC.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GONGC +hex
  c flags: Optim=1
  c include: .\source\wlib\sys;.\source\wlib\delay;.\user;.\source\FWLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start
    ./source/startup/: cortexm3_macro.s stm32f10x_vector.s
  group user
    ./user/: main.c stm32f10x_it.c
  group lib
    ./source/wlib/delay/: delay.c
    ./source/FWLib/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c
    ./source/wlib/sys/: RCC_Configuration.c
